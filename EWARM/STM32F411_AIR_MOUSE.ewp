# IAR project STM32F411_AIR_MOUSE.ewp, settings and files
configuration STM32F411_AIR_MOUSE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; USE_FULL_LL_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/cwm; ../Src/cwm/algo; ../Src/cwm/driver; ../Src/cwm/customIntf; ../Src/cwm/osTask; ../Src/cwm/variant; ../Src/custm
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F411_AIR_MOUSE.out
  ILINK.IlinkIcfFile: stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration cwm_air_mouse_lib (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Src/cwm; ../Src/cwm/algo; ../Src/cwm/driver; ../Src/cwm/customIntf; ../Src/cwm/osTask; ../Src/cwm/variant
  OBJCOPY.OOCOutputFile: STM32F411_AIR_MOUSE.srec
  group Application/EWARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/custm
    ../Src/custm/: cwm_sample task.c
  group Application/User/cwm
    ../Src/cwm/: cwmAlgorithmHal.c cwmApp.c cwmCalibrator.c cwmDriverHal.c
  group Application/User/cwm/algo
    ../Src/cwm/algo/: cwm_air_mouse_V00.01.00_20171108_IAR.o cwm_common_utility_float_V00.09.07_20170725_IAR.o cwm_fusion_ExMem_V03.15.05_20171106_IAR.o
  group Application/User/cwm/customIntf
    ../Src/cwm/customIntf/: customIntf.c
  group Application/User/cwm/driver
    ../Src/cwm/driver/: DriverBMI160_SPI.c
  group Application/User/cwm/osTask
    ../Src/cwm/osTask/: cwmTaskCmd.c cwmTaskSen.c
  group Application/User/cwm/variant
    ../Src/cwm/variant/: cwmGpioConfig.c cwmSpiMaster.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
